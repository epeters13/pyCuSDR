options:
  parameters:
    author: Edwin G. W. Peters
    copyright: Edwin G. W. Peters
    description: Loopback example with the bladeRF
    generate_options: qt_gui
    id: blade_graph
    output_language: python
    title: blade loopback
  states: {}

blocks:
- name: F_offset_Hz
  id: variable
  parameters:
    value: 20*baud
  states: {}
- name: Fc_Hz
  id: variable
  parameters:
    value: 437.3e6
  states: {}
- name: baud
  id: variable
  parameters:
    value: '7416'
  states: {}
- name: freq_offset_Hz
  id: variable_qtgui_range
  parameters:
    label: Frequency offset [Hz
    orient: Qt.Horizontal
    start: '-1e5'
    step: '1'
    stop: 1e5
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 128*baud
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '0'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: Fc_Hz-F_offset_Hz+freq_offset_Hz
    gain0: tx_gain
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=0,agc_mode=''manual''"'
    bb_gain0: '20'
    freq0: Fc_Hz-F_offset_Hz
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5560
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5571
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5560
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', zeromq_pub_sink_0, '0']
- [zeromq_pull_source_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
