options:
  parameters:
    author: Edwin G. W. Peters
    copyright: Edwin G. W. Peters
    generate_options: qt_gui
    id: uhd_graph
    output_language: python
    title: UHD loopback
  states: {}

blocks:
- name: F_offset_Hz
  id: variable
  parameters:
    value: 20*baud
  states: {}
- name: Fc_Hz
  id: variable
  parameters:
    value: 437.3e6
  states: {}
- name: baud
  id: variable
  parameters:
    value: '7416'
  states: {}
- name: freq_offset_Hz
  id: variable_qtgui_range
  parameters:
    label: Frequency offset [Hz
    orient: Qt.Horizontal
    start: '-1e5'
    step: '1'
    stop: 1e5
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 128*baud
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: Fc_Hz-F_offset_Hz+freq_offset_Hz
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: Fc_Hz-F_offset_Hz
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5560
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5571
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5560
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', zeromq_pub_sink_0, '0']
- [uhd_usrp_source_0, '0', zeromq_push_sink_0, '0']
- [zeromq_pull_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
